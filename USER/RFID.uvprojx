# Keil uVision project RFID.uvprojx, settings and files
target RFID (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RFID +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\RC522;..\HARDWARE\OLED;..\HARDWARE\KEY44;..\HARDWARE\RTC;..\HARDWARE\DOOR;..\HARDWARE\SIM900A;..\HARDWARE\USART2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RC522/: rc522.c 522Init.c
    ../HARDWARE/OLED/: OLED_I2C.c
    ../HARDWARE/KEY44/: key44.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DOOR/: door.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/SIM900A/: sim900a.c
    ../HARDWARE/USART2/: usart2.c
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
